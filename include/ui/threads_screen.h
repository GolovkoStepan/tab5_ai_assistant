#pragma once

// Экран списка тредов: открытие, создание, удаление.
//
// До этого экрана тред выбирался только по времени: после перезагрузки
// открывался самый свежий, а прошлые разговоры достать было нельзя вообще.
// Список читает с карты только первые строки каждого треда (заголовок), поэтому
// вход на экран не превращается в чтение мегабайт.
//
// Переименования нет намеренно: заголовком служит первый вопрос пользователя, и
// отдельное имя пришлось бы хранить в служебной строке meta, которую v0.2.0
// ещё не пишет. Правка вопроса задним числом исказила бы историю разговора,
// которую видит модель.
//
// Экран НЕ переключает себя сам и не открывает тред: он выставляет запрос
// (take_selected_slug, take_new_request), а выполняет его main. Иначе экран
// знал бы про ChatScreen, и получилась бы взаимная зависимость двух экранов.

#include <stddef.h>
#include <stdint.h>

#include "hw/chat_store.h"
#include "hw/keyboard.h"

namespace ui {

class ThreadsScreen {
public:
    /// Длина поискового запроса.
    static constexpr size_t kMaxQuery = 64;

    /// Привязать к хранилищу. Вызывается один раз в setup().
    void init(hw::ChatStore& store);

    /// Открыть экран: перечитать список с карты.
    void onEnter();

    /// Обработать событие клавиатуры.
    /// @return true, если экран нужно закрыть
    bool onKey(const hw::KeyEvent& ev);

    /// Обработать касание: выбор строки, повторный тап — открыть.
    /// @return true, если запрошено открытие (см. take_selected_slug)
    bool onTouch(int x, int y);

    /// Периодическая работа не нужна: список статичен между перечитываниями.
    void tick() {}

    /// Перерисовать помеченное изменившимся.
    void draw();

    /// Есть ли что перерисовывать.
    ///
    /// Смена выбора тоже работа: внутри неподвижного окна она рисует две
    /// строки. Раньше этот случай не считался работой, и подсветка стояла на
    /// прежней строке, пока список не доскроллится до края.
    bool dirty() const
    {
        // _list_valid проверяется и здесь: до первой отрисовки сдвигать нечего,
        // и сравнение _drawn_first (−1) с _first дало бы вечную «грязь».
        if (_redraw_all) return true;
        if (!_list_valid) return true;
        if (_drawn_first != _first) return true;
        return _drawn_selected != _selected;
    }

    /// Забыть взведённое подтверждение при выходе.
    void onExit();

    /// Какой тред просят открыть. Пусто — не просили.
    ///
    /// Возвращается внутренний буфер, действительный до следующего onKey() или
    /// onTouch(). Вызывающий обязан скопировать имя, если оно ему нужно дольше.
    const char* take_selected_slug();

    /// Сбросить запрос на открытие (вызывающий уже обработал его).
    void clear_request();

    /// Просили создать новый тред. Сбрасывает запрос.
    bool take_new_request();

    /// Удалили тред, который был ОТКРЫТ в чате. Сбрасывает флаг.
    ///
    /// Экран не создаёт тред взамен: это работа ChatScreen, и только он умеет
    /// сбросить ленту, поле ввода и измерения. Здесь только факт.
    bool take_open_removed();

    /// Показать сообщение в строке ошибки (например, «идёт ответ»).
    void notice(const char* text);

    /// Сообщить экрану, идёт ли сейчас ответ модели.
    ///
    /// Нужно для одной проверки: нельзя удалить ОТКРЫТЫЙ тред во время
    /// стриминга. Удаление очищает арену треда, а в неё в этот момент пишется
    /// ответ — вместо «удалили файл» получили бы порчу памяти.
    void set_chat_busy(bool busy) { _chat_busy = busy; }

private:
    void reload();
    /// Перечитать страницу, начиная с `_page_offset`.
    void reload_page();
    void clamp_scroll();

    /// Есть ли треды дальше показанной страницы.
    bool has_next_page() const { return shown_count() < _total; }
    /// Есть ли треды до показанной страницы.
    bool has_prev_page() const { return _page_offset > 0; }
    void next_page();
    void prev_page();
    /// Сколько показано с учётом страницы — для «N из M».
    size_t shown_count() const { return _page_offset + _count; }
    /// Начать ввод поискового запроса.
    void begin_search();
    /// Выполнить поиск по введённому запросу.
    void run_search();
    /// Отменить поиск и вернуться к полному списку.
    void clear_search();

    /// Перерисовать две строки, между которыми переехал выбор.
    ///
    /// Список перерисовывается целиком только при прокрутке окна и перечитывании
    /// с карты. На стрелку меняется подсветка двух строк, и рисовать все
    /// пятнадцать (по четыре надписи в каждой) при автоповторе 80 мс — это
    /// заметные рывки.
    ///
    /// Стирается именно та строка, которая нарисована подсвеченной
    /// (_drawn_selected), а не та, что была выбрана до нажатия: между кадрами
    /// может пройти несколько нажатий, и прежний выбор к моменту отрисовки уже
    /// не совпадает с нарисованным.
    void draw_selection();
    void draw_header();
    void draw_list();
    void draw_row(int row, bool fill_bg);
    void draw_scrollbar();

    /// Сдвинуть готовое изображение списка и дорисовать открывшуюся строку.
    ///
    /// Как и лента чата, список прокручивается сдвигом, а не перерисовкой: у
    /// панели один фреймбуфер, и полная отрисовка пятнадцати строк на каждое
    /// нажатие стрелки (автоповтор 80 мс) видна как мерцание.
    ///
    /// @return false, если сдвиг невозможен и нужна полная перерисовка
    bool shift_list();

    /// Запомнить окно и число тредов на момент отрисовки списка.
    void remember_list();
    void draw_footer();
    void draw_hints();
    void fail(const char* text);

    /// Удалить выбранный тред. Второй вызов с тем же выбором — подтверждение.
    void remove_selected(bool confirmed);

    hw::ChatStore* _store{nullptr};

    /// Список с карты. Заполняется reload().
    hw::ChatStore::ThreadInfo _items[hw::ChatStore::kMaxListedThreads]{};
    size_t _count{0};
    /// Сколько тредов всего (или найдено поиском) — для «N из M».
    size_t _total{0};
    /// С какого треда начинается показанная страница.
    size_t _page_offset{0};
    /// Идёт ввод поискового запроса: клавиши набирают текст, а не двигают выбор.
    bool _searching{false};
    bool _from_search{false};
    char _query[kMaxQuery]{};
    int _selected{0};
    /// Прокрутка: первая показанная строка.
    int _first{0};

    /// Тред, удаление которого ждёт подтверждения. -1 — ничего не ждёт.
    ///
    /// Подтверждение привязано к имени треда, а не к номеру строки: если список
    /// успел перечитаться, удалять надо именно тот тред, который выбрали.
    int _armed{-1};
    char _armed_slug[48]{};
    /// Заголовок того же треда — для вопроса в подтверждении. Имя файла
    /// (`chat-20261124-120000`) пользователю ничего не говорит.
    char _armed_title[112]{};

    /// Строка ошибки или сообщения. _notice_ok — это подтверждение действия, а
    /// не ошибка: цвет другой.
    char _error[160]{};
    bool _notice_ok{false};

    /// Имя треда, открытие которого запрошено.
    char _selected_slug[48]{};
    bool _open_request{false};
    bool _new_request{false};
    bool _open_removed{false};

    /// Идёт ответ модели (см. set_chat_busy).
    bool _chat_busy{false};

    /// Окно и число тредов на момент отрисовки списка: по ним видно, можно ли
    /// обойтись сдвигом изображения.
    int _drawn_first{-1};
    size_t _drawn_count{0};
    bool _list_valid{false};

    /// Выбор, который реально нарисован на экране. Стирать подсветку надо
    /// именно здесь, а не на номере, который был до нажатия: кадры могут
    /// пропускаться (несколько нажатий до перерисовки), и тогда на экране
    /// оставалась бы подсветка давно не выбранной строки — «зелёные рамки» на
    /// строках, которые уже не выбраны.
    int _drawn_selected{-1};

    /// Экран только что открыли: нужно стереть всё, что показывал прежний
    /// экран. Отдельно от _redraw_all: полная перерисовка бывает и после
    /// удаления треда, и стирать весь экран тогда незачем — это заметное
    /// чёрное мигание.
    bool _need_clear{true};

    bool _redraw_all{true};
};

}  // namespace ui
